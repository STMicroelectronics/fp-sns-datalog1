# Keil uVision project Project.uvprojx, settings and files
target HSDatalog-STBOX (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L4R9ZITx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: IROM(0x08000000-0x81FFFFF) IROM2(0x0-0xFFFFFFFFFFFFFFFF) IRAM(0x20000000-0x2009FFFF) IRAM2(0x0-0xFFFFFFFFFFFFFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Project +hex
  AfterMake: fromelf #L --bin --output=$L@L.bin
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32L4R9xx,USE_HAL_DRIVER,ARM_MATH_CM4,USE_HAL_DFSDM_REGISTER_CALLBACKS,USE_HAL_ADC_REGISTER_CALLBACKS,USE_HAL_SAI_REGISTER_CALLBACKS,USE_HAL_SPI_REGISTER_CALLBACKS,USE_HAL_TIM_REGISTER_CALLBACKS,USE_HAL_I2C_REGISTER_CALLBACKS,USE_HAL_TIM_REGISTER_CALLBACKS
  c misc: --wchar32
  c include: ../Inc;../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../Drivers/BSP/Components/stts751;../../../../../Drivers/BSP/Components/hts221;../../../../../Drivers/BSP/Components/lps22hh;../../../../../Drivers/BSP/Components/lis2mdl;../../../../../Drivers/BSP/Components/lsm6dsox;../../../../../Drivers/BSP/Components/lps22hh;../../../../../Drivers/BSP/Components/lis3dhh;../../../../../Drivers/BSP/Components/lis2dw12;../../../../../Drivers/BSP/Components/Common;../../../../../Drivers/BSP/SensorTile.box;../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/SensorStreaming_WCID/Inc;../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../../../../../Middlewares/ST/BlueNRG-2/hci/hci_tl_patterns/Basic;../../../../../Middlewares/ST/BlueNRG-2/includes;../../../../../Middlewares/ST/BlueNRG-2/utils;../../../../../Middlewares/Third_Party/FatFs/src;../../../../../Middlewares/Third_Party/FatFs/src/drivers;../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../Middlewares/ST/Audio/C/lib/inc;../../../../../Middlewares/Third_Party/parson;../HSDCore/Inc
  asm include: ../Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0xc4ffffff size 0xc1038f0b
  memory RVCT9: RAM 0x20000000 size 0xa0000
  memory RVCT10: RAM 0xc4ffffff size 0xc1038f0b
  group Application/MDK-ARM
    ./: startup_stm32l4r9xx.s
  group Application/User
    ../Src/: Automode.c AutoModeTask.c cpu_utils.c main.c sdcard_manager.c sd_diskio.c stm32l4xx_it.c usbd_conf.c usbd_desc.c usbd_wcid_interface.c OTA.c
  group Application/User/BLE_Config
    ../Src/: ble_comm_manager.c ble_config_service.c hci_tl_interface.c ble_comm_transfer_protocol.c
  group Application/User/HSDCore
    ../HSDCore/Src/: com_manager.c device_description.c HSD_json.c HSD_tags.c sensors_manager.c hts221_app.c lis2dw12_app.c lis2mdl_app.c lis3dhh_app.c lps22hh_app.c lsm6dsox_app.c mp23abs1_app.c stts751_app.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/hts221/: hts221_reg.c
    ../../../../../Drivers/BSP/Components/lis2dw12/: lis2dw12_reg.c
    ../../../../../Drivers/BSP/Components/lis2mdl/: lis2mdl_reg.c
    ../../../../../Drivers/BSP/Components/lis3dhh/: lis3dhh_reg.c
    ../../../../../Drivers/BSP/Components/lps22hh/: lps22hh_reg.c
    ../../../../../Drivers/BSP/Components/lsm6dsox/: lsm6dsox_reg.c
    ../../../../../Drivers/BSP/Components/stts751/: stts751_reg.c
  group Drivers/BSP/SensorTile.box
    ../../../../../Drivers/BSP/SensorTile.box/: SensorTile.box.c SensorTile.box_bc.c SensorTile.box_sd.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_dfsdm_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_exti.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_opamp.c stm32l4xx_hal_opamp_ex.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_rtc.c stm32l4xx_hal_sai.c stm32l4xx_hal_sai_ex.c stm32l4xx_hal_sd.c stm32l4xx_hal_sd_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_usart_ex.c stm32l4xx_ll_sdmmc.c stm32l4xx_ll_usb.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c
  group Middlewares
    ../../../../../Middlewares/Third_Party/parson/: parson.c
  group Middlewares/Class/WCID
    ../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/SensorStreaming_WCID/Src/: usbd_wcid_streaming.c
  group Middlewares/Core
    ../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Middlewares/FatFs/Core
    ../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/FatFs/Options
    ../../../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group Middlewares/FreeRTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
  group Middlewares/FreeRTOS/CMSIS_RTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/FreeRTOS/portable
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/X-CUBE-BLE2/Wireless/Controller
    ../../../../../Middlewares/ST/BlueNRG-2/hci/controller/: bluenrg1_gap_aci.c bluenrg1_gatt_aci.c bluenrg1_hal_aci.c bluenrg1_l2cap_aci.c
  group Middlewares/X-CUBE-BLE2/Wireless/HCI_TL/Basic
    ../../../../../Middlewares/ST/BlueNRG-2/hci/: bluenrg1_events.c bluenrg1_events_cb.c bluenrg1_hci_le.c
    ../../../../../Middlewares/ST/BlueNRG-2/hci/hci_tl_patterns/Basic/: hci_tl.c
  group Middlewares/X-CUBE-BLE2/Wireless/Utils
    ../../../../../Middlewares/ST/BlueNRG-2/utils/: ble_list.c
software components: CMSIS:CORE 5.4.0, CMSIS:DSP 1.8.0
